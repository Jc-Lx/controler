# Keil uVision project CONTROLER.uvprojx, settings and files
target CONTROLER (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CONTROLER +hex
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\User\uart;..\User\key;..\User\led;..\User\74hc165;..\User\adc;..\User\soft_iic;..\User\iic_ee.c;..\User\delay;..\User\spi1;..\User\nrf24l01p;..\User\pwm;..\TASK;..\User\beeper
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group TASK
    ../TASK/: TaskConfig.h read_task.c send_task.c
  group USER
    ../User/: FreeRTOSConfig.h main.c stm32f4xx_it.c
    ../User/beeper/: beeper.c
    ../User/uart/: bsp_debug_usart.c
    ../User/led/: bsp_led.c
    ../User/74hc165/: 74hc165.c
    ../User/adc/: adc.c
    ../User/soft_iic/: soft_iic_gpio.c
    ../User/iic_ee.c/: iic_ee.c
    ../User/delay/: delay.c
    ../User/spi1/: spi1.c
    ../User/nrf24l01p/: nrf24l01p.c
    ../User/pwm/: pwm.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
